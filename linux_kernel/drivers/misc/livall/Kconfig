## linux_kernel/drivers/misc/livall/Kconfig
```kconfig
config LIVALL_BOARDVERSION
	bool "Create sysfs to detect HW board version"
	depends on SYSFS_LIVALL
	default y
```
